LXI H,2050H
MOV C,M;option
INX H
MOV A,M;NUMBER:1
INX H
MOV B,M;NUMBER:2
DCR C
JZ L1ADD
DCR C
JZ L2SUB
DCR C
JZ L3MULTI
DCR C
JZ L4DIV
DCR C
JZ L5CMPL
DCR C
JZ L62COMP
;ADDITION
L1ADD:ADD B
STA 2053H
JMP FINAL
;SUBTRACTION
L2SUB:SUB B
STA 2053H
JMP FINAL
;MULTIPLICATION
L3MULTI:MOV D,A; NUMBER:1 IS NOW IN Dregister
MVI A,00H
MVI E,00H;CARRY
LOOP2:ADD B
JNC LOOP1
INR E
LOOP1:DCR D
JNZ LOOP2
STA 2053H
JMP FINAL
;DIVISION
L4DIV: MVI C,00H ;QUOTIENT
LOOP:SUB B
INR C
CMP B
JNC LOOP
STA 2053H;REMAINDER
MOV A,C
STA 2054H;QUOTIENT
JMP FINAL
;1'S COMPLEMENT
L5CMPL:CMA
STA 2053H;COMPLEMENT OF 1'ST NUMBER
MOV A,B
CMA
STA 2054H;COMPLEMENT OF 2nd NUMBER
JMP FINAL
;2'S COMPLEMENT
L62COMP:CMA
ADI 01H
STA 2053H
MOV A,B
CMA
ADI 01H
STA 2054H
JMP FINAL
FINAL:HLT
